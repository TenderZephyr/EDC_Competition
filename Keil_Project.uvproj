# Keil uVision project Keil_Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Keil_Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c GPIO.c STC15Fxxxx.H GPIO.h BH1750FVI.c delay.c DHT11.c DS18B20.c MQ_2.c oled.c uart.c wifi_control.c OLED_IIc.c OLED_IIc.h oled.h
